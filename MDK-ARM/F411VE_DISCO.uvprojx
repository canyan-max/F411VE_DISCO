# Keil uVision project F411VE_DISCO.uvprojx, settings and files
target F411VE_DISCO (6220000::V6.22::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F411VE_DISCO +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE,USER_DEBUG_LOG,USER_IDLE_LOG
  c include: ../Core/Inc;../USB_HOST/App;../USB_HOST/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/MP3;../Middlewares/EasyLog/Inc;../Middlewares/EasyLog/Src;../Middlewares/RTT;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Middlewares/Kfifo;../FATFS/Target;../FATFS/App;..\00_Common;..\01_App;..\01_App\player_task;..\01_App\uart_task;..\01_App\decode_task;..\02_Service;..\02_Service\player;..\02_Service\sd;..\02_Service\uart;..\03_Device\audio_out;..\04_Bsp\cs43l22;..\04_Bsp\uart;..\04_Bsp\dwt;..\05_McuImpl\cs43lxxx_hal;..\05_McuImpl\uart_hal
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c i2s.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio_spi.c user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Middlewares/Mp3
    ../Middlewares/MP3/: minimp3.h
  group Middlewares/EasyLog
    ../Middlewares/EasyLog/Src/: elog.c elog_async.c elog_buf.c elog_port.c elog_utils.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/Kfifo
    ../Middlewares/Kfifo/: kfifo.c kfifo.h
  group Middlewares/RTT
    ../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group 00_Common
    ../00_Common/: platform_error.h
  group 01_App
    ../01_App/: app_boot.c
    ../01_App/uart_task/: uart_task.c
    ../01_App/player_task/: player_task.c
    ../01_App/decode_task/: decode_task.c
  group 02_Service
    ../02_Service/player/: service_mp3_player.c
    ../02_Service/sd/: service_sd_manager.c
    ../02_Service/uart/: service_uart_manager.c
  group 03_Device
    ../03_Device/audio_out/: device_audio_out.c
  group 04_Bsp/cs43l22
    ../04_Bsp/cs43l22/: bsp_cs43lxxx_drv.c
  group 04_Bsp/uart
    ../04_Bsp/uart/: bsp_uart.h
  group 05_McuImpl
    ../05_McuImpl/cs43lxxx_hal/: mcu_cs43lxxx_hal.c
    ../05_McuImpl/uart_hal/: mcu_uart_hal.c
software components: CMSIS:CORE 6.1.1
